## conf/local.conf
```bitbake
include "application.conf"

filePrefix = "/Users/v-yaroslavskyi/TradeHub/SudoBot/"
```
